# Keil uVision project inodes-d405-bl.uvprojx, settings and files
target d405-bl (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: d405-bl
  AfterMake: fromelf --bin -o  ./release/d405-bl.bin ./obj/d405-bl.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_CL PROJ_NEWPWRCTRL BOOT_LOADER
  c include: .\;..\midware;..\board\chip\stm32f107\CMSIS\CM3\CoreSupport;..\board\chip\stm32f107\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\board\chip\stm32f107\Driver\inc;..\board\bsp;..\board\hal;..\midware\MQTT;..\midware\setting;..\apps;..\rtos\rtt\include;..\rtos\rtt\components\dfs\include;..\rtos\rtt\components\finsh;..\rtos\rtt\components\drivers\include;..\rtos\rtt\components\net\lwip-2.1.2\src;..\rtos\rtt\components\net\lwip-2.1.2\src\include;..\rtos\rtt\components\net\lwip-2.1.2\src\include\ipv4;..\rtos\rtt\components\net\lwip-2.1.2\src\arch\include;..\rtos\rtt\components\net\lwip-2.1.2\src\include\netif;..\rtos\rtt\components\dfs\filesystems\elmfat;..\rtos\osal
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group apps
    ../apps/: version.c
  group bsphal
    ../board/bsp/: stm32f10x_it.c nextai_flash.c
  group driver
    ../board/chip/stm32f107/Driver/src/: misc.c stm32f10x_crc.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_iwdg.c stm32f10x_gpio.c stm32f10x_usart.c
  group system
    ../apps/: bootstart.c
    ../board/bsp/: bootboard.c retarget.c
    ../board/chip/stm32f107/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../board/chip/stm32f107/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../board/chip/stm32f107/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
software components: CMSIS:CORE 5.3.0
