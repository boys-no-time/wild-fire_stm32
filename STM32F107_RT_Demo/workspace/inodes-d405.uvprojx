# Keil uVision project inodes-d405.uvprojx, settings and files
target inodes-d405 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: inodes-d405
  AfterMake: fromelf --bin -o  ./release/inodes-d405.bin ./obj/inodes-d405.axf
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_CL PROJ_NEWPWRCTRL DEBUG
  c include: .\;..\midware;..\board\chip\stm32f107\CMSIS\CM3\CoreSupport;..\board\chip\stm32f107\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\board\chip\stm32f107\Driver\inc;..\board\bsp;..\midware\MQTT;..\midware\setting;..\apps;..\rtos\rtt\include;..\rtos\rtt\components\drivers\include;..\rtos\rtt\components\drivers\include\drivers;..\rtos\rtt\components\drivers\include\ipc;..\rtos\rtt\components\net\lwip-2.1.2\src;..\rtos\rtt\components\net\lwip-2.1.2\src\include;..\rtos\rtt\components\net\lwip-2.1.2\src\arch\include;..\board\hal
  memory RVCT4: ROM 0x8004000 size 0x3c000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group apps
    ../apps/: application.c startup.c swdog.c boardtest.c fw_upgrade.c crc8.c com_master.c version.c
  group bsphal
    ../board/bsp/: board.c stm32f10x_it.c usart.c platform.c stm32_eth.c rt_stm32f10x_spi.c nextai_flash.c exboard.c
    ../board/hal/: hal_com.c hal_led.c ds1302.c hal_key.c
  group driver
    ../board/chip/stm32f107/Driver/src/: misc.c stm32f10x_crc.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_iwdg.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_tim.c
  group midware
    ../midware/: inodes_port.c
    ../midware/MQTT/: mqtt_client.c nextai_mqtt.c
    ../midware/setting/: cJSON.c nextai_setting.c
  group rtt
    ../rtos/rtt/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
    ../rtos/rtt/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../rtos/rtt/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../rtos/rtt/components/drivers/serial/: serial.c
    ../rtos/rtt/components/drivers/src/: completion.c dataqueue.c
  group system
    ../board/chip/stm32f107/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../board/chip/stm32f107/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../board/chip/stm32f107/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
    ../board/bsp/: retarget.c
  group LwIP
    ../rtos/rtt/components/net/lwip-2.1.2/src/arch/: sys_arch.c
    ../rtos/rtt/components/net/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../rtos/rtt/components/net/lwip-2.1.2/src/core/: def.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c inet_chksum.c ip.c
    ../rtos/rtt/components/net/lwip-2.1.2/src/core/ipv4/: dhcp.c autoip.c icmp.c ip4.c ip4_addr.c ip4_frag.c etharp.c
    ../rtos/rtt/components/net/lwip-2.1.2/src/core/ipv6/: dhcp6.c inet6.c ip6_addr.c ip6_frag.c
    ../rtos/rtt/components/net/lwip-2.1.2/src/netif/: ethernet.c ethernetif.c
  group doc
    ../doc/: readme.txt
software components: CMSIS:CORE 5.3.0
