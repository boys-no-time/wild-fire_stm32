# Keil uVision project Project.uvprojx, settings and files
target inodes-d405-demo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: obj
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_CL
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;.\sys;..\Libraries\3.1.3\components\finsh;..\Libraries\3.1.3\include\libc;..\Libraries\3.1.3\include;..\Libraries\3.1.3\bsp;.\bsphal
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group Doc
    ./: readme.txt
  group SYS
    ./sys/: debug.c delay.c retarget.c stm32f10x_it.c sys.c
  group APP
    ./app/: main.c board.h
    ../Libraries/3.1.3/bsp/: board.c rtconfig.h
  group Bsphal
    ./bsphal/: ds1302.c hal_key.c hal_led.c
  group lwip3.13
    ../Libraries/3.1.3/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
    ../Libraries/3.1.3/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
software components: CMSIS:CORE 5.4.0
